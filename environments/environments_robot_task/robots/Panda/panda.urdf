Commit message: Fix pick-place expert

File: environments/environments_robot_task/robots/Panda/panda.urdf (robot description, URDF)
Before this commit: robot panda, 12 links, 11 joints
Joints:
- joint tcp: origin xyz=0 0 0.105 rpy=3.14159 0 0 -> xyz=0 0 0.105 rpy=0 0 0
